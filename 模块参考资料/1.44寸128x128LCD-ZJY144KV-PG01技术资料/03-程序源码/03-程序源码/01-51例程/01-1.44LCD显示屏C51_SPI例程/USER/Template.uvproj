# Keil uVision project Template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\USER;..\HARDWARE\LCD
  group USER
    ./: STARTUP.A51 main.c
  group HARDWARE
    ../HARDWARE/LCD/: lcd.c lcd_init.c spi.c
