# Keil uVision project RA8D2.uvprojx, settings and files
target RA8D2_512K (6240000::V6.24::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: RA8D2_512K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8D2_512K, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x2000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x22000000 size 0x1a0000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target RA8D2_1M (6240000::V6.24::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA8D2_1M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8D2_1M, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x2000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x22000000 size 0x1a0000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
target RA8D2_CONF (6240000::V6.24::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA8D2_CONF
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8D2_CONF, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x2000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x22000000 size 0x1a0000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
target RA8D2_OTP (6240000::V6.24::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA8D2_OTP
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8D2_OTP, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x2000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x22000000 size 0x1a0000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
target RA8D2_SiP_8M (6240000::V6.24::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA8D2_SiP_8M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8D2_SiP_8M, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x2000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x22000000 size 0x1a0000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
target RA8D2_SiP_4M (6240000::V6.24::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA8D2_SiP_4M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8D2_SiP_4M, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x2000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x22000000 size 0x1a0000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
