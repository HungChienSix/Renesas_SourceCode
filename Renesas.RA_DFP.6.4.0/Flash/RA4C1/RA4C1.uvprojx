# Keil uVision project RA4C1.uvprojx, settings and files
target RA4C1_512K (6220000::V6.22::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: RA4C1_512K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4C1_512K,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target RA4C1_256K (6220000::V6.22::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA4C1_256K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4C1_256K,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
target RA4C1_512K_DL (6220000::V6.22::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA4C1_512K_DL
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4C1_512K_dual_lower ,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
target RA4C1_512K_DU (6220000::V6.22::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA4C1_512K_DU
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4C1_512K_dual_upper,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
target RA4C1_256K_DL (6220000::V6.22::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA4C1_256K_DL
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4C1_256K_dual_lower ,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
target RA4C1_256K_DU (6220000::V6.22::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA4C1_256K_DU
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4C1_256K_dual_upper ,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
target RA4C1_DATA_C512K (6220000::V6.22::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA4C1_DATA_C512K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4C1_DATA,CODE_512K,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
target RA4C1_DATA_C256K (6220000::V6.22::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA4C1_DATA_C256K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4C1_DATA,CODE_256K,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
target RA4C1_DATA_C512K_D (6220000::V6.22::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA4C1_DATA_C512K_D
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4C1_DATA,CODE_512K_dual,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
target RA4C1_DATA_C256K_D (6220000::V6.22::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA4C1_DATA_C256K_D
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4C1_DATA,CODE_256K_dual,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x200000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
target RA4C1_CONF (6220000::V6.22::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA4C1_CONF
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4C1_CONF,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
