# Keil uVision project RA8M1.uvprojx, settings and files
target RA8M1_1M (6190000::V6.19::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x30000000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x10000000,0x00200000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: RA8M1_1M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8M1_1M,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target RA8M1_1M_DL (6190000::V6.19::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA8M1_1M_DL
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8M1_1M_DL, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA8M1_1M_DU (6190000::V6.19::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA8M1_1M_DU
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8M1_1M_DU, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA8M1_2M (6190000::V6.19::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA8M1_2M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8M1_2M, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA8M1_2M_DL (6190000::V6.19::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA8M1_2M_DL
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8M1_2M_DL, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA8M1_2M_DU (6190000::V6.19::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA8M1_2M_DU
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8M1_2M_DU, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA8M1_DATA_C1M (6190000::V6.19::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA8M1_DATA_C1M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8M1_DATA, CODE_1M, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA8M1_DATA_C2M (6190000::V6.19::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA8M1_DATA_C2M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8M1_DATA, CODE_2M, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA8M1_DATA_C1M_D (6190000::V6.19::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA8M1_DATA_C1M_D
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8M1_DATA, CODE_1M_dual, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA8M1_DATA_C2M_D (6190000::V6.19::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA8M1_DATA_C2M_D
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8M1_DATA, CODE_2M_dual, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA8M1_CCONF (6190000::V6.19::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA8M1_CCONF
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8M1_CCONF, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA8M1_DCONF (6190000::V6.19::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA8M1_DCONF
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8M1_DCONF, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
