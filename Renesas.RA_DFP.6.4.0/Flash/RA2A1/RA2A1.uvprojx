# Keil uVision project RA2A1.uvprojx, settings and files
target RA2A1_256K (6190000::V6.19::ARMCLANG)
  device: ARMCM23 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: RA2A1_256K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=5 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA2A1_256K,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x40100000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target RA2A1_CONF (6190000::V6.19::ARMCLANG)
  device: ARMCM23 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA2A1_CONF
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=5 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA2A1_CONF,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x40100000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA2A1_DATA (6190000::V6.19::ARMCLANG)
  device: ARMCM23 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA2A1_DATA
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=5 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA2A1_DATA,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x40100000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
