# Keil uVision project RA8E1.uvprojx, settings and files
target RA8E1_1M (6220000::V6.22::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x30000000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x10000000,0x00200000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: RA8E1_1M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8E1_1M, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target RA8E1_1M_DL (6220000::V6.22::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA8E1_1M_DL
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8E1_1M_DL, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA8E1_1M_DU (6220000::V6.22::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA8E1_1M_DU
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8E1_1M_DU, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA8E1_DATA_C1M (6220000::V6.22::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA8E1_DATA_C1M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8E1_DATA, CODE_1M, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA8E1_CCONF (6220000::V6.22::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA8E1_CCONF
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8E1_CCONF, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA8E1_DCONF (6220000::V6.22::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA8E1_DCONF
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8E1_DCONF, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA8E1_DATA_C1M_D (6220000::V6.22::ARMCLANG)
  device: ARMCM85 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA8E1_DATA_C1M_D
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA8E1_DATA,  CODE_1M_dual, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
