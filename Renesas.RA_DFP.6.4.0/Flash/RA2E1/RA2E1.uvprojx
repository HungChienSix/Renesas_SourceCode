# Keil uVision project RA2E1.uvprojx, settings and files
target RA2E1_128KB (6190000::V6.19::ARMCLANG)
  device: R7FA2E1A5 Renesas
  pack: Renesas.RA_DFP.5.1.0
  cpu: CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: RA2E1_128K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=5 v6Lang=3 v6LangP=3 wLevel=2
  c define: RA2E1_128K,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x40100000 size 0x1000
  memory RVCT9: RAM 0x20004000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target RA2E1_64KB (6190000::V6.19::ARMCLANG)
  device: R7FA2E1A5 Renesas
  pack: Renesas.RA_DFP.5.1.0
  cpu: CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: RA2E1_64K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=5 v6Lang=3 v6LangP=3 wLevel=2
  c define: RA2E1_64K,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x40100000 size 0x1000
  memory RVCT9: RAM 0x20004000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA2E1_32KB (6190000::V6.19::ARMCLANG)
  device: R7FA2E1A5 Renesas
  pack: Renesas.RA_DFP.5.1.0
  cpu: CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: RA2E1_32K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=5 v6Lang=3 v6LangP=3 wLevel=2
  c define: RA2E1_32K,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x40100000 size 0x1000
  memory RVCT9: RAM 0x20004000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA2E1_DATA (6190000::V6.19::ARMCLANG)
  device: R7FA2E1A5 Renesas
  pack: Renesas.RA_DFP.5.1.0
  cpu: CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: RA2E1_DATA
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=5 v6Lang=3 v6LangP=3 wLevel=2
  c define: RA2E1_DATA,CHG_CLK_AND_MOD_ENA
  asm misc: --diag_suppress L6305
  asm include: .\Target.lin
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x40100000 size 0x1000
  memory RVCT9: RAM 0x20004000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA2E1_CONF (6190000::V6.19::ARMCLANG)
  device: R7FA2E1A5 Renesas
  pack: Renesas.RA_DFP.5.1.0
  cpu: CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: RA2E1_CONF
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=5 v6Lang=3 v6LangP=3 wLevel=2
  c define: RA2E1_CONF,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x40100000 size 0x1000
  memory RVCT9: RAM 0x20004000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
