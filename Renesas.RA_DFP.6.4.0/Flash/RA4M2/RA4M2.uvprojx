# Keil uVision project RA4M2.uvprojx, settings and files
target RA4M2_512K (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: RA4M2_512K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4M2_512K, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target RA4M2_384K (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA4M2_384K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4M2_384K, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA4M2_256K (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA4M2_256K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4M2_256K, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA4M2_CONF (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA4M2_CONF
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4M2_CONF, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA4M2_DATA_C512K (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA4M2_DATA_C512K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4M2_DATA, CODE_512K,  CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA4M2_DATA_C384K (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA4M2_DATA_C384K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4M2_DATA, CODE_384K, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA4M2_DATA_C256K (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA4M2_DATA_C256K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4M2_DATA,CODE_256K,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
