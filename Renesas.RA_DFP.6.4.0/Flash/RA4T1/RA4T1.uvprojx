# Keil uVision project RA4T1.uvprojx, settings and files
target RA4T1_DATA_CODE_256K (6190000::V6.19::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") CLOCK(12000000) ESEL ELITTLE
  output: RA4T1_DATA_C256K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4T1_DATA, CODE_256K. CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target RA4T1_256K (6190000::V6.19::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA4T1_256K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4T1_256K, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA4T1_128K (6190000::V6.19::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA4T1_128K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4T1_128K, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA4T1_DATA_CODE_128K (6190000::V6.19::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA4T1_DATA_C128K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4T1_DATA, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA4T1_CONF (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: RA4T1_CONF
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA4T1_CONF, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
