# Keil uVision project RA6M1_2_3.uvprojx, settings and files
target RA6M3_2M (6190000::V6.19::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: RA6M3_2M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CHG_CLK_AND_MOD_ENA, RA6M3_2M
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target RA6M3_1M (6190000::V6.19::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M3_1M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CHG_CLK_AND_MOD_ENA, RA6M3_1M
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M2_1M (6190000::V6.19::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M2_1M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CHG_CLK_AND_MOD_ENA, RA6M2_1M
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M2_512K (6190000::V6.19::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M2_512K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CHG_CLK_AND_MOD_ENA, RA6M2_512K
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M1_512K (6190000::V6.19::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M1_512K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CHG_CLK_AND_MOD_ENA, RA6M1_512K
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M3_DATA_C2M (6190000::V6.19::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M3_DATA_C2M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CHG_CLK_AND_MOD_ENA, RA6M3_DATA, CODE_2M
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M3_DATA_C1M (6190000::V6.19::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M3_DATA_C1M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CHG_CLK_AND_MOD_ENA, RA6M3_DATA
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M2_DATA_C1M (6190000::V6.19::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M2_DATA_C1M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CHG_CLK_AND_MOD_ENA, RA6M2_DATA, CODE_1M
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M2_DATA_C512K (6190000::V6.19::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M2_DATA_C512K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CHG_CLK_AND_MOD_ENA, RA6M2_DATA
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M1_DATA (6190000::V6.19::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M1_DATA
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CHG_CLK_AND_MOD_ENA, RA6M1_DATA
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M1_CONF (6190000::V6.19::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M1_CONF
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CHG_CLK_AND_MOD_ENA, RA6M1_CONF
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M2_CONF (6190000::V6.19::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M2_CONF
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CHG_CLK_AND_MOD_ENA, RA6M2_CONF
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M3_CONF (6190000::V6.19::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M3_CONF
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CHG_CLK_AND_MOD_ENA, RA6M3_CONF
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
