# Keil uVision project RA6M5.uvprojx, settings and files
target RA6M5_2M (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BH Renesas
  pack: Renesas.RA_DFP.6.3.0-alpha.0
  cpu: IRAM(0x20000000,0x080000) IROM(0x00000000,0x200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: RA6M5_2M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M5_2M, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c FlashOS.h
target RA6M5_2M_dual_lower (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BH Renesas
  pack: Renesas.RA_DFP.6.3.0-alpha.0
  cpu: as above
  output: RA6M5_2M_DL
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M5_2M_dual_lower, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M5_2M_dual_upper (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BH Renesas
  pack: Renesas.RA_DFP.6.3.0-alpha.0
  cpu: as above
  output: RA6M5_2M_DU
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M5_2M_dual_upper, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M5_1_dot_5M (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BG Renesas
  pack: Renesas.RA_DFP.6.3.0-alpha.0
  cpu: IRAM(0x20000000,0x080000) IROM(0x00000000,0x180000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: RA6M5_1_dot_5M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M5_1_dot_5M, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M5_1_dot_5M_dual_lower (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BG Renesas
  pack: Renesas.RA_DFP.6.3.0-alpha.0
  cpu: as above
  output: RA6M5_1_dot_5M_DL
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M5_1_dot_5M_dual_lower, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M5_1_dot_5M_dual_upper (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BG Renesas
  pack: Renesas.RA_DFP.6.3.0-alpha.0
  cpu: as above
  output: RA6M5_1_dot_5M_DU
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M5_1_dot_5M_dual_upper, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M5_1M (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.6.3.0-alpha.0
  cpu: IRAM(0x20000000,0x080000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: RA6M5_1M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M5_1M, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M5_1M_dual_lower (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.6.3.0-alpha.0
  cpu: as above
  output: RA6M5_1M_DL
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M5_1M_dual_lower, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M5_1M_dual_upper (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.6.3.0-alpha.0
  cpu: as above
  output: RA6M5_1M_DU
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M5_1M_dual_upper, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M5_DATA_C2M (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BH Renesas
  pack: Renesas.RA_DFP.6.3.0-alpha.0
  cpu: as above
  output: RA6M5_DATA_C2M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M5_DATA, CODE_2M, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M5_DATA_C1dot5M (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BG Renesas
  pack: Renesas.RA_DFP.6.3.0-alpha.0
  cpu: as above
  output: RA6M5_DATA_C1dot5M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M5_DATA, CODE_1_dot_5M, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M5_DATA_C1M (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.6.3.0-alpha.0
  cpu: as above
  output: RA6M5_DATA_C1M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M5_DATA, CODE_1M,  CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M5_CONF (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BH Renesas
  pack: Renesas.RA_DFP.6.3.0-alpha.0
  cpu: as above
  output: RA6M5_CONF
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M5_CONF, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M5_DATA_C1M_dual (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.6.3.0-alpha.0
  cpu: as above
  output: RA6M5_DATA_C1M_D
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M5_DATA, CODE_1M_dual, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M5_DATA_C2M_dual (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BH Renesas
  pack: Renesas.RA_DFP.6.3.0-alpha.0
  cpu: as above
  output: RA6M5_DATA_C2M_D
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M5_DATA, CODE_2M_dual, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M5_DATA_C1dot5M_dual (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BG Renesas
  pack: Renesas.RA_DFP.6.3.0-alpha.0
  cpu: as above
  output: RA6M5_DATA_C1dot5M_D
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M5_DATA, CODE_1_dot_5M_dual, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
