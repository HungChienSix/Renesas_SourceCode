# Keil uVision project RA6M4.uvprojx, settings and files
target RA6M4_1M (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: RA6M4_1M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M4_1M,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target RA6M4_1M_DL (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M4_1M_DL
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M4_1M_dual_lower,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M4_1M_DU (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M4_1M_DU
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M4_1M_dual_upper,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M4_768K (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M4_768K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M4_768K,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M4_768K_DL (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M4_768K_DL
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M4_768K_dual_lower,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M4_768K_DU (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M4_768K_DU
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M4_768K_dual_upper,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M4_512K (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M4_512K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M4_512K,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M4_512K_DL (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M4_512K_DL
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M4_512K_dual_lower,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M4_512K_DU (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M4_512K_DU
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M4_512K_dual_upper,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M4_DATA_C1M (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M4_DATA_C1M
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M4_DATA, CODE_1M, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M4_DATA_C1M_D (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M4_DATA_C1M_D
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M4_DATA, CODE_1M_dual, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M4_DATA_C768K (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M4_DATA_C768K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M4_DATA, CODE_768K, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M4_DATA_C768K_D (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M4_DATA_C768K_D
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M4_DATA, CODE_768K, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M4_DATA_C512K (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M4_DATA_C512K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M4_DATA, CODE_512K, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M4_DATA_C512K_D (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M4_DATA_C512K_D
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M4_DATA, CODE_512K_dual, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target RA6M4_CONF (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: RA6M4_CONF
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA6M4_CONF, CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
