# Keil uVision project RA0E3.uvprojx, settings and files
target RA0E3_16KB (6240000::V6.24::..\..\..\Toolchain\ArmCompilerforEmbedded6.24)
  device: ARMCM23 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: RA0E3_16K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA0E3_16K
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target RA0E3_CONF (6240000::V6.24::..\..\..\Toolchain\ArmCompilerforEmbedded6.24)
  device: ARMCM23 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA0E3_CONF
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA0E3_CONF
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
