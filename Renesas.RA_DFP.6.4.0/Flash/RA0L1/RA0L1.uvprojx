# Keil uVision project RA0L1.uvprojx, settings and files
target RA0L1_64KB (6220000::V6.22::ARMCLANG)
  device: ARMCM23 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: RA0L1_64K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA0L1_64K,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20004000 size 0x4000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target RA0L1_32KB (6220000::V6.22::ARMCLANG)
  device: ARMCM23 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA0L1_32K
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA0L1_32K,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20004000 size 0x4000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
target RA0L1_DATA (6220000::V6.22::ARMCLANG)
  device: ARMCM23 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA0L1_DATA
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA0L1_DATA,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20004000 size 0x4000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
target RA0L1_CONF (6220000::V6.22::ARMCLANG)
  device: ARMCM23 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: RA0L1_CONF
  AfterMake: cmd.exe /C copy "Objects\%L" "..\.\@L.FLM"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RA0L1_CONF,CHG_CLK_AND_MOD_ENA
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20004000 size 0x4000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
